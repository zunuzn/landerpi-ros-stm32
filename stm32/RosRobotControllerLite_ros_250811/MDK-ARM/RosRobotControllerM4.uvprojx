# Keil uVision project RosRobotControllerM4.uvprojx, settings and files
target RosRobotControllerM4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RosRobotControllerM4 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Third_Party/Fusion/Fusion;../Third_Party/U8g2;../Third_Party/RTT;../Third_Party/Lw;../Third_Party;../Hiwonder/LVGL_UI/guider_customer_fonts;../Hiwonder/LVGL_UI/guider_fonts;../Hiwonder/LVGL_UI/images;../Hiwonder/LVGL_UI;../Hiwonder/Peripherals;../Hiwonder/Portings;../Hiwonder/Chassis;../Hiwonder/System;../Hiwonder/Misc
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Third_Party/RTT
    ../Third_Party/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Third_Party/Fusion
    ../Third_Party/Fusion/Fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group Third_Party/LW
    ../Third_Party/Lw/: lwmem.c lwmem_sys_cmsis_os.c lwpkt.c lwrb.c lwshell.c
  group Third_party/U8g2
    ../Third_Party/U8g2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_stdio.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Hiwonder/Peripherals
    ../Hiwonder/Peripherals/: button.c buzzer.c led.c pwm_servo.c serial_servo.c encoder_motor.c QMI8658.c rgb_spi.c
  group Hiwonder/Misc
    ../Hiwonder/Misc/: checksum.c log.h log.c packet.c pid.c syscall.c object.h
  group Hiwonder/Chassis
    ../Hiwonder/Chassis/: chassis.h differential_chassis.c differential_chassis.h mecanum_chassis.c mecanum_chassis.h
  group Hiwonder/Porting
    ../Hiwonder/Portings/: led_porting.c button_porting.c buzzer_porting.c imu_porting.c motors_param.h motor_porting.c packet_porting.c pwm_servo_porting.c lwmem_porting.c chassis_porting.c u8g2_porting.c serial_servo_porting.c IIC.c
  group Hiwonder/System
    ../Hiwonder/System/: global_conf.h global.h battery_handle.c app.c packet_handle.c packet_handle.h oled_handle.c
  group Doc
    ../Doc/: log.txt
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
